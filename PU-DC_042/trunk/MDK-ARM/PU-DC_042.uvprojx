# Keil uVision project PU-DC_042.uvprojx, settings and files
target PU-DC_042 (ARM-ADS)
  device: STM32F072C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: PU-DC_042
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Src;../Src/WIZCHIP;../Src/WIZCHIP/Ethernet;../Src/WIZCHIP/Ethernet/W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_uart.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd.c stm32f0xx_hal_spi.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_spi_ex.c
  group Application/User
    ../Src/: usb_device.c usbd_cdc_if.c usbd_conf.c stm32f0xx_hal_msp.c main.c usbd_desc.c stm32f0xx_it.c I2C.c Coders.c RS232.c flash.c ESP-07.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group WizNet lib
    ../Src/WIZCHIP/Ethernet/: wizchip_conf.c socket.c
    ../Src/WIZCHIP/Ethernet/W5500/: w5500.c
  group Interfaces
    ../Src/WIZCHIP/: ifs_ethernet.c
software components: CMSIS:CORE 4.1.0
